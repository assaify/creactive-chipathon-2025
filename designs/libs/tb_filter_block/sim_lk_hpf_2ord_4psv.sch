v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
L 4 2090 -1080 2090 -980 {dash=10}
L 4 2350 -1100 2530 -1100 {dash=10}
L 4 2090 -1080 2170 -1080 {dash=10}
L 4 2020 -1120 2170 -1120 {dash=10}
L 4 1820 -1560 1870 -1560 {dash=10}
L 4 1630 -1560 1680 -1560 {dash=10}
L 4 2530 -1100 2710 -1100 {dash=10}
L 4 2620 -1100 2620 -910 {dash=10}
L 4 2090 -980 2090 -910 {dash=10}
L 4 2090 -910 2620 -910 {dash=10}
L 4 1420 -1120 2020 -1120 {dash=10
}
L 4 890 -1120 1180 -1120 {dash=10
}
L 4 1790 -1120 1790 -1030 {dash=10}
L 4 1790 -790 1790 -700 {dash=10}
L 4 1180 -1120 1230 -1120 {dash=10}
L 4 1370 -1120 1420 -1120 {dash=10}
L 4 1030 -1560 1630 -1560 {dash=10}
L 4 1870 -1560 2620 -1560 {dash=10}
L 4 1030 -1560 1030 -1120 {dash=10}
L 4 2620 -1560 2620 -1100 {dash=10}
L 4 470 -1120 650 -1120 {dash=10}
L 4 1790 -840 1790 -790 {dash=10}
L 4 1790 -1030 1790 -980 {dash=10}
L 4 650 -1120 700 -1120 {dash=10}
L 4 840 -1120 890 -1120 {dash=10}
B 2 1830 -570 2630 -170 {flags=graph
y1=-77.276411
y2=-28.566801
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0
node="\\"R=10k; gpio_a1 db20()\\"%0
\\"R=20k; gpio_a1 db20()\\"%1
\\"R=30k; gpio_a1 db20()\\"%2
\\"R=40k; gpio_a1 db20()\\"%3
\\"R=50k; gpio_a1 db20()\\"%4
\\"R=60k; gpio_a1 db20()\\"%5
\\"R=70k; gpio_a1 db20()\\"%6
\\"R=80k; gpio_a1 db20()\\"%7
\\"R=90k; gpio_a1 db20()\\"%8
\\"R=100k; gpio_a1 db20()\\"%9"
color="4 5 6 7 8 9 10 11 12 13"
dataset=-1
unitx=1
logx=1
logy=0
x2=9}
B 4 2085 -985 2095 -975 {}
B 4 2525 -1105 2535 -1095 {}
B 4 2015 -1125 2025 -1115 {}
B 4 1865 -1565 1875 -1555 {}
B 4 1785 -1035 1795 -1025 {}
B 4 1785 -795 1795 -785 {}
B 4 1175 -1125 1185 -1115 {}
B 4 1415 -1125 1425 -1115 {}
B 4 1625 -1565 1635 -1555 {}
B 4 645 -1125 655 -1115 {}
B 4 885 -1125 895 -1115 {}
P 4 5 2020 -1290 2020 -980 2530 -980 2530 -1290 2020 -1290 {}
P 4 5 1960 -1030 1460 -1030 1460 -790 1960 -790 1960 -1030 {}
P 4 5 1630 -1730 1630 -1230 1870 -1230 1870 -1730 1630 -1730 {}
P 4 5 1180 -850 1420 -850 1420 -1310 1180 -1310 1180 -850 {}
P 4 5 2840 -1700 2840 -1010 3220 -1010 3220 -1700 2840 -1700 {}
P 4 5 3240 -1700 3240 -1010 3620 -1010 3620 -1700 3240 -1700 {}
P 4 5 3640 -1700 3640 -1010 4020 -1010 4020 -1700 3640 -1700 {}
P 4 5 4040 -1700 4040 -1010 4420 -1010 4420 -1700 4040 -1700 {}
P 4 5 4440 -1700 4440 -1010 4820 -1010 4820 -1700 4440 -1700 {}
P 4 5 2840 -940 2840 -250 3220 -250 3220 -940 2840 -940 {}
P 4 5 3240 -940 3240 -250 3620 -250 3620 -940 3240 -940 {}
P 4 5 3640 -940 3640 -250 4020 -250 4020 -940 3640 -940 {}
P 4 5 4040 -940 4040 -250 4420 -250 4420 -940 4040 -940 {}
P 4 5 4440 -940 4440 -250 4820 -250 4820 -940 4440 -940 {}
P 4 5 650 -850 890 -850 890 -1310 650 -1310 650 -850 {}
T {GPIO_A1} 2630 -1090 0 0 0.4 0.4 {}
T {GPIO_A3} 1690 -1110 0 0 0.4 0.4 {}
T {GPIO_A4} 1050 -1540 0 0 0.4 0.4 {}
T {1} 630 -1110 0 0 0.3 0.3 {layer=4}
T {GPIO_A2} 1810 -730 0 0 0.4 0.4 {}
T {GPIO_A0} 490 -1150 0 0 0.4 0.4 {}
T {2} 2540 -1090 0 0 0.3 0.3 {layer=4}
T {3} 2100 -970 0 0 0.3 0.3 {layer=4}
T {4} 1880 -1550 0 0 0.3 0.3 {layer=4}
T {5} 1800 -780 0 0 0.3 0.3 {layer=4}
T {6} 2000 -1110 0 0 0.3 0.3 {layer=4}
T {7} 1800 -1060 0 0 0.3 0.3 {layer=4}
T {10} 900 -1110 0 0 0.3 0.3 {layer=4}
T {11} 1600 -1550 0 0 0.3 0.3 {layer=4}
T {R1} 1640 -1270 0 0 0.4 0.4 {}
T {C2} 1190 -880 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A0} 2840 -1730 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A1} 3240 -1730 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A2} 3640 -1730 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A3} 4040 -1730 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A4} 4440 -1730 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A5} 2840 -970 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A6} 3240 -970 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A7} 3640 -970 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A8} 4040 -970 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A9} 4440 -970 0 0 0.4 0.4 {}
T {R2} 1470 -830 0 0 0.4 0.4 {}
T {8} 1430 -1110 0 0 0.3 0.3 {layer=4}
T {9} 1160 -1110 0 0 0.3 0.3 {layer=4}
T {C1} 660 -880 0 0 0.4 0.4 {}
N 2300 -1190 2360 -1190 {lab=#net1}
N 2360 -1270 2360 -1190 {lab=#net1}
N 2360 -1270 2410 -1270 {lab=#net1}
C {libs/core_analog/single_ended_ota/single_ended_ota.sym} 2260 -1100 0 0 {name=xa1}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 3010 -1600 0 0 {name=x6}
C {lab_pin.sym} 2350 -1100 3 1 {name=p1 sig_type=std_logic lab=P1}
C {lab_pin.sym} 2170 -1080 3 0 {name=p2 sig_type=std_logic lab=P2}
C {lab_pin.sym} 2260 -1010 0 0 {name=p23 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2260 -1190 0 0 {name=p24 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2920 -1630 0 0 {name=p68 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 2920 -1610 0 0 {name=p69 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 3100 -1630 0 1 {name=p70 sig_type=std_logic lab=P22}
C {lab_pin.sym} 3100 -1610 0 1 {name=p71 sig_type=std_logic lab=GPIO_A0}
C {lab_pin.sym} 3100 -1570 0 1 {name=p72 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3100 -1590 0 1 {name=p73 sig_type=std_logic lab=VSSd}
C {isource.sym} 2300 -1220 0 0 {name=I0 value=83u}
C {lab_pin.sym} 2300 -1250 0 0 {name=p191 sig_type=std_logic lab=VDD}
C {devices/code_shown.sym} 15 -2008.75 0 0 {name=Simulation only_toplevel=false value="
vdr[1] dr[1] 0 dc 0
vdr[2] dr[2] 0 dc 0
vdr[3] dr[3] 0 dc 0
vdr[4] dr[4] 0 dc 0
vdr[5] dr[5] 0 dc 0

vdr[6] dr[6] 0 dc 0
vdr[7] dr[7] 0 dc 0
vdr[8] dr[8] 0 dc 0
vdr[9] dr[9] 0 dc 0
vdr[10] dr[10] 0 dc 0

vdrb[1] drb[1] 0 dc 3.3
vdrb[2] drb[2] 0 dc 3.3
vdrb[3] drb[3] 0 dc 3.3
vdrb[4] drb[4] 0 dc 3.3
vdrb[5] drb[5] 0 dc 3.3

vdrb[6] drb[6] 0 dc 3.3
vdrb[7] drb[7] 0 dc 3.3
vdrb[8] drb[8] 0 dc 3.3
vdrb[9] drb[9] 0 dc 3.3
vdrb[10] drb[10] 0 dc 3.3

vvdd VDD 0 dc 3.3
vvss VSS 0 dc 0

vvddd VDDd 0 dc 3.3
vvssd VSSd 0 dc 0

vgpio_a2 GPIO_A2 0 dc 0
vgpio_a0 GPIO_A0 0 dc 1.65 ac 1

.nodeset all=3.3
.control
alter vdr[1] = 3.3
alter vdrb[1] = 0
save GPIO_A1
ac dec 1000 1 100e6
write sim_lk_hpf_2ord_4psv.raw
set appendwrite

reset
alter vdr[2] = 3.3
alter vdrb[2] = 0
save GPIO_A1
ac dec 1000 1 100e6
write sim_lk_hpf_2ord_4psv.raw

reset
alter vdr[3] = 3.3
alter vdrb[3] = 0
save GPIO_A1
ac dec 1000 1 100e6
write sim_lk_hpf_2ord_4psv.raw

reset
alter vdr[4] = 3.3
alter vdrb[4] = 0
save GPIO_A1
ac dec 1000 1 100e6
write sim_lk_hpf_2ord_4psv.raw

reset
alter vdr[5] = 3.3
alter vdrb[5] = 0
save GPIO_A1
ac dec 1000 1 100e6
write sim_lk_hpf_2ord_4psv.raw

reset
alter vdr[6] = 3.3
alter vdrb[6] = 0
save GPIO_A1
ac dec 1000 1 100e6
write sim_lk_hpf_2ord_4psv.raw

reset
alter vdr[7] = 3.3
alter vdrb[7] = 0
save GPIO_A1
ac dec 1000 1 100e6
write sim_lk_hpf_2ord_4psv.raw

reset
alter vdr[8] = 3.3
alter vdrb[8] = 0
save GPIO_A1
ac dec 1000 1 100e6
write sim_lk_hpf_2ord_4psv.raw

reset
alter vdr[9] = 3.3
alter vdrb[9] = 0
save GPIO_A1
ac dec 1000 1 100e6
write sim_lk_hpf_2ord_4psv.raw

reset
alter vdr[10] = 3.3
alter vdrb[10] = 0
save GPIO_A1
ac dec 1000 1 100e6
write sim_lk_hpf_2ord_4psv.raw
.endc
"}
C {devices/code_shown.sym} 612.5 -317.5 0 0 {name=Models only_toplevel=false
format="tcleval( @value )"
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
.lib $::180MCU_MODELS/sm141064.ngspice res_typical
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_typical
.include /foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_sc_mcu9t5v0/spice/gf180mcu_fd_sc_mcu9t5v0.spice
"}
C {launcher.sym} 1890 -150 0 0 {name=h5
descr="load waves" 
tclcommand="xschem raw_read $netlist_dir/sim_filter_block_tgate.raw ac"
}
C {lab_pin.sym} 2170 -1120 1 0 {name=p6 sig_type=std_logic lab=P3}
C {libs/core_passive_array/sim_res_10x10k/sim_res_10x10k.sym} 1750 -1560 3 0 {name=xr1}
C {lab_pin.sym} 1680 -1560 3 0 {name=p204 sig_type=std_logic lab=P46}
C {lab_pin.sym} 1820 -1560 3 0 {name=p205 sig_type=std_logic lab=P47}
C {lab_pin.sym} 1750 -1650 3 1 {name=p211 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1770 -1650 3 1 {name=p212 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 1790 -1650 3 1 {name=p213 sig_type=std_logic lab=VSSd}
C {libs/core_passive_array/sim_cap_10x1p/sim_cap_10x1p.sym} 1300 -1120 3 0 {name=xc2}
C {lab_pin.sym} 1230 -1120 3 0 {name=p218 sig_type=std_logic lab=P24}
C {lab_pin.sym} 1370 -1120 3 0 {name=p219 sig_type=std_logic lab=P25}
C {lab_pin.sym} 1320 -1210 3 1 {name=p220 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 1340 -1210 3 1 {name=p221 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 1290 -1030 3 0 {name=p222 sig_type=std_logic lab="10*VDDd"}
C {lab_pin.sym} 1310 -1030 3 0 {name=p223 sig_type=std_logic lab="10*VSSd"}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 3410 -1600 0 0 {name=x1}
C {lab_pin.sym} 3320 -1630 0 0 {name=p3 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3320 -1610 0 0 {name=p4 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 3500 -1630 0 1 {name=p5 sig_type=std_logic lab=P1}
C {lab_pin.sym} 3500 -1610 0 1 {name=p7 sig_type=std_logic lab=GPIO_A1}
C {lab_pin.sym} 3500 -1570 0 1 {name=p8 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3500 -1590 0 1 {name=p9 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 3810 -1600 0 0 {name=x2}
C {lab_pin.sym} 3720 -1630 0 0 {name=p10 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3720 -1610 0 0 {name=p11 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 3900 -1630 0 1 {name=p16 sig_type=std_logic lab=P49}
C {lab_pin.sym} 3900 -1610 0 1 {name=p17 sig_type=std_logic lab=GPIO_A2}
C {lab_pin.sym} 3900 -1570 0 1 {name=p18 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3900 -1590 0 1 {name=p19 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 4210 -1600 0 0 {name=x3}
C {lab_pin.sym} 4120 -1630 0 0 {name=p20 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4120 -1610 0 0 {name=p21 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 4300 -1630 0 1 {name=p22 sig_type=std_logic lab=P3}
C {lab_pin.sym} 4300 -1610 0 1 {name=p31 sig_type=std_logic lab=GPIO_A3}
C {lab_pin.sym} 4300 -1570 0 1 {name=p32 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4300 -1590 0 1 {name=p33 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 4610 -1600 0 0 {name=x4}
C {lab_pin.sym} 4700 -1630 0 1 {name=p34 sig_type=std_logic lab=P23}
C {lab_pin.sym} 4700 -1610 0 1 {name=p35 sig_type=std_logic lab=GPIO_A4}
C {lab_pin.sym} 4700 -1570 0 1 {name=p36 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4700 -1590 0 1 {name=p37 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 3410 -1500 0 0 {name=x11}
C {lab_pin.sym} 3320 -1530 0 0 {name=p82 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3320 -1510 0 0 {name=p83 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 3500 -1530 0 1 {name=p84 sig_type=std_logic lab=P2}
C {lab_pin.sym} 3500 -1510 0 1 {name=p85 sig_type=std_logic lab=GPIO_A1}
C {lab_pin.sym} 3500 -1470 0 1 {name=p86 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3500 -1490 0 1 {name=p87 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 3410 -1400 0 0 {name=x12}
C {lab_pin.sym} 3320 -1430 0 0 {name=p88 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3320 -1410 0 0 {name=p89 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 3500 -1430 0 1 {name=p90 sig_type=std_logic lab=P47}
C {lab_pin.sym} 3500 -1410 0 1 {name=p91 sig_type=std_logic lab=GPIO_A1}
C {lab_pin.sym} 3500 -1370 0 1 {name=p92 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3500 -1390 0 1 {name=p93 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 4210 -1500 0 0 {name=x13}
C {lab_pin.sym} 4120 -1530 0 0 {name=p94 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4120 -1510 0 0 {name=p95 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 4300 -1530 0 1 {name=p96 sig_type=std_logic lab=P25}
C {lab_pin.sym} 4300 -1510 0 1 {name=p97 sig_type=std_logic lab=GPIO_A3}
C {lab_pin.sym} 4300 -1470 0 1 {name=p98 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4300 -1490 0 1 {name=p99 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 4210 -1400 0 0 {name=x14}
C {lab_pin.sym} 4120 -1430 0 0 {name=p100 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4120 -1410 0 0 {name=p101 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 4300 -1430 0 1 {name=p102 sig_type=std_logic lab=P48}
C {lab_pin.sym} 4300 -1410 0 1 {name=p103 sig_type=std_logic lab=GPIO_A3}
C {lab_pin.sym} 4300 -1370 0 1 {name=p104 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4300 -1390 0 1 {name=p105 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 4520 -1630 0 0 {name=p106 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4520 -1610 0 0 {name=p107 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 4610 -1500 0 0 {name=x15}
C {lab_pin.sym} 4700 -1530 0 1 {name=p108 sig_type=std_logic lab=P24}
C {lab_pin.sym} 4700 -1510 0 1 {name=p109 sig_type=std_logic lab=GPIO_A4}
C {lab_pin.sym} 4700 -1470 0 1 {name=p110 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4700 -1490 0 1 {name=p111 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 4520 -1530 0 0 {name=p112 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4520 -1510 0 0 {name=p113 sig_type=std_logic lab=VSSd}
C {libs/core_passive_array/sim_res_10x10k/sim_res_10x10k.sym} 1790 -910 0 0 {name=xr2}
C {lab_pin.sym} 1790 -980 0 0 {name=p50 sig_type=std_logic lab=P48}
C {lab_pin.sym} 1790 -840 0 0 {name=p51 sig_type=std_logic lab=P49}
C {lab_pin.sym} 1880 -910 0 1 {name=p58 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1880 -890 0 1 {name=p59 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 1880 -870 0 1 {name=p64 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 4610 -1400 0 0 {name=x5}
C {lab_pin.sym} 4700 -1430 0 1 {name=p12 sig_type=std_logic lab=P46}
C {lab_pin.sym} 4700 -1410 0 1 {name=p13 sig_type=std_logic lab=GPIO_A4}
C {lab_pin.sym} 4700 -1370 0 1 {name=p14 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4700 -1390 0 1 {name=p15 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 4520 -1430 0 0 {name=p25 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4520 -1410 0 0 {name=p26 sig_type=std_logic lab=VSSd}
C {libs/core_passive_array/sim_cap_10x1p/sim_cap_10x1p.sym} 770 -1120 3 0 {name=xc1}
C {lab_pin.sym} 700 -1120 3 0 {name=p29 sig_type=std_logic lab=P22}
C {lab_pin.sym} 840 -1120 3 0 {name=p30 sig_type=std_logic lab=P23}
C {lab_pin.sym} 790 -1210 3 1 {name=p38 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 810 -1210 3 1 {name=p39 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 760 -1030 3 0 {name=p40 sig_type=std_logic lab="10*VDDd"}
C {lab_pin.sym} 780 -1030 3 0 {name=p41 sig_type=std_logic lab="10*VSSd"}
C {libs/core_analog/single_ended_ota/bias.sym} 2410 -1190 0 0 {name=x8}
C {lab_pin.sym} 2410 -1130 0 1 {name=p67 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1700 -920 0 0 {name=p27 sig_type=std_logic lab="DR[1:10]"}
C {lab_pin.sym} 1700 -900 0 0 {name=p28 sig_type=std_logic lab="DRb[1:10]"}
C {lab_pin.sym} 1740 -1470 3 0 {name=p42 sig_type=std_logic lab="DR[1:10]"}
C {lab_pin.sym} 1760 -1470 3 0 {name=p43 sig_type=std_logic lab="DRb[1:10]"}
