v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
L 4 2340 -1050 2340 -950 {dash=10}
L 4 2600 -1070 2780 -1070 {dash=10}
L 4 2340 -1050 2420 -1050 {dash=10}
L 4 2270 -1090 2420 -1090 {dash=10}
L 4 2070 -1530 2120 -1530 {dash=10}
L 4 1880 -1530 1930 -1530 {dash=10}
L 4 2780 -1070 2960 -1070 {dash=10}
L 4 2870 -1070 2870 -880 {dash=10}
L 4 2340 -950 2340 -880 {dash=10}
L 4 2340 -880 2870 -880 {dash=10}
L 4 1670 -1090 2270 -1090 {dash=10
}
L 4 1140 -1090 1430 -1090 {dash=10
}
L 4 2040 -1090 2040 -1000 {dash=10}
L 4 2040 -760 2040 -670 {dash=10}
L 4 1430 -1090 1480 -1090 {dash=10}
L 4 1620 -1090 1670 -1090 {dash=10}
L 4 1280 -1530 1880 -1530 {dash=10}
L 4 2120 -1530 2870 -1530 {dash=10}
L 4 1280 -1530 1280 -1090 {dash=10}
L 4 2870 -1530 2870 -1070 {dash=10}
L 4 720 -1090 900 -1090 {dash=10}
L 4 2040 -810 2040 -760 {dash=10}
L 4 2040 -1000 2040 -950 {dash=10}
L 4 900 -1090 950 -1090 {dash=10}
L 4 1090 -1090 1140 -1090 {dash=10}
B 2 2080 -540 2880 -140 {flags=graph
y1=-57.551214
y2=-46.851647
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.40793213
x2=8.1905448
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0
node="\\"Magnitude (dB); gpio_a1 db20()\\""
color=4
dataset=-1
unitx=1
logx=1
logy=0
hcursor2_y=-48.478186
hcursor1_y=-51.481911}
B 4 2335 -955 2345 -945 {}
B 4 2775 -1075 2785 -1065 {}
B 4 2265 -1095 2275 -1085 {}
B 4 2115 -1535 2125 -1525 {}
B 4 2035 -1005 2045 -995 {}
B 4 2035 -765 2045 -755 {}
B 4 1425 -1095 1435 -1085 {}
B 4 1665 -1095 1675 -1085 {}
B 4 1875 -1535 1885 -1525 {}
B 4 895 -1095 905 -1085 {}
B 4 1135 -1095 1145 -1085 {}
P 4 5 2270 -1260 2270 -950 2780 -950 2780 -1260 2270 -1260 {}
P 4 5 2210 -1000 1710 -1000 1710 -760 2210 -760 2210 -1000 {}
P 4 5 1880 -1700 1880 -1200 2120 -1200 2120 -1700 1880 -1700 {}
P 4 5 1430 -820 1670 -820 1670 -1280 1430 -1280 1430 -820 {}
P 4 5 3090 -1670 3090 -980 3470 -980 3470 -1670 3090 -1670 {}
P 4 5 3490 -1670 3490 -980 3870 -980 3870 -1670 3490 -1670 {}
P 4 5 3890 -1670 3890 -980 4270 -980 4270 -1670 3890 -1670 {}
P 4 5 4290 -1670 4290 -980 4670 -980 4670 -1670 4290 -1670 {}
P 4 5 4690 -1670 4690 -980 5070 -980 5070 -1670 4690 -1670 {}
P 4 5 3090 -910 3090 -220 3470 -220 3470 -910 3090 -910 {}
P 4 5 3490 -910 3490 -220 3870 -220 3870 -910 3490 -910 {}
P 4 5 3890 -910 3890 -220 4270 -220 4270 -910 3890 -910 {}
P 4 5 4290 -910 4290 -220 4670 -220 4670 -910 4290 -910 {}
P 4 5 4690 -910 4690 -220 5070 -220 5070 -910 4690 -910 {}
P 4 5 900 -820 1140 -820 1140 -1280 900 -1280 900 -820 {}
T {GPIO_A1} 2880 -1060 0 0 0.4 0.4 {}
T {GPIO_A3} 1940 -1080 0 0 0.4 0.4 {}
T {GPIO_A4} 1300 -1510 0 0 0.4 0.4 {}
T {1} 880 -1080 0 0 0.3 0.3 {layer=4}
T {GPIO_A2} 2060 -700 0 0 0.4 0.4 {}
T {GPIO_A0} 740 -1120 0 0 0.4 0.4 {}
T {2} 2790 -1060 0 0 0.3 0.3 {layer=4}
T {3} 2350 -940 0 0 0.3 0.3 {layer=4}
T {4} 2130 -1520 0 0 0.3 0.3 {layer=4}
T {5} 2050 -750 0 0 0.3 0.3 {layer=4}
T {6} 2250 -1080 0 0 0.3 0.3 {layer=4}
T {7} 2050 -1030 0 0 0.3 0.3 {layer=4}
T {10} 1150 -1080 0 0 0.3 0.3 {layer=4}
T {11} 1850 -1520 0 0 0.3 0.3 {layer=4}
T {R1} 1890 -1240 0 0 0.4 0.4 {}
T {C2} 1440 -850 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A0} 3090 -1700 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A1} 3490 -1700 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A2} 3890 -1700 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A3} 4290 -1700 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A4} 4690 -1700 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A5} 3090 -940 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A6} 3490 -940 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A7} 3890 -940 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A8} 4290 -940 0 0 0.4 0.4 {}
T {TGATE BUS: GPIO_A9} 4690 -940 0 0 0.4 0.4 {}
T {R2} 1720 -800 0 0 0.4 0.4 {}
T {8} 1680 -1080 0 0 0.3 0.3 {layer=4}
T {9} 1410 -1080 0 0 0.3 0.3 {layer=4}
T {C1} 910 -850 0 0 0.4 0.4 {}
C {libs/core_analog/single_ended_ota/single_ended_ota.sym} 2510 -1070 0 0 {name=xa1}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 3260 -1570 0 0 {name=x6}
C {lab_pin.sym} 2600 -1070 3 1 {name=p1 sig_type=std_logic lab=P1}
C {lab_pin.sym} 2420 -1050 3 0 {name=p2 sig_type=std_logic lab=P2}
C {lab_pin.sym} 2510 -980 0 0 {name=p23 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2510 -1160 0 0 {name=p24 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 3170 -1600 0 0 {name=p68 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3170 -1580 0 0 {name=p69 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 3350 -1600 0 1 {name=p70 sig_type=std_logic lab=P22}
C {lab_pin.sym} 3350 -1580 0 1 {name=p71 sig_type=std_logic lab=GPIO_A0}
C {lab_pin.sym} 3350 -1540 0 1 {name=p72 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3350 -1560 0 1 {name=p73 sig_type=std_logic lab=VSSd}
C {isource.sym} 2550 -1190 0 0 {name=I0 value=83u}
C {lab_pin.sym} 2550 -1220 0 0 {name=p191 sig_type=std_logic lab=VDD}
C {devices/code_shown.sym} 35 -548.75 0 0 {name=Simulation only_toplevel=false value="
vvdd VDD 0 dc 3.3
vvss VSS 0 dc 0

vvddd VDDd 0 dc 3.3
vvssd VSSd 0 dc 0

vgpio_a2 GPIO_A2 0 dc 0
vgpio_a0 GPIO_A0 0 dc 1.65 ac 1

.nodeset all=3.3
.control
    save GPIO_A1
    ac dec 1000 1 100e6
    write sim_lk_hpf_2ord_4psv.raw
.endc
"}
C {devices/code_shown.sym} 42.5 -167.5 0 0 {name=Models only_toplevel=false
format="tcleval( @value )"
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
.lib $::180MCU_MODELS/sm141064.ngspice res_typical
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_typical
.include /foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_sc_mcu9t5v0/spice/gf180mcu_fd_sc_mcu9t5v0.spice
"}
C {launcher.sym} 2140 -120 0 0 {name=h5
descr="load waves" 
tclcommand="xschem raw_read $netlist_dir/sim_filter_block_tgate.raw ac"
}
C {lab_pin.sym} 2420 -1090 1 0 {name=p6 sig_type=std_logic lab=P3}
C {libs/core_passive_array/sim_res_10x10k/sim_res_10x10k.sym} 2000 -1530 3 0 {name=xr1}
C {lab_pin.sym} 1930 -1530 3 0 {name=p204 sig_type=std_logic lab=P46}
C {lab_pin.sym} 2070 -1530 3 0 {name=p205 sig_type=std_logic lab=P47}
C {lab_pin.sym} 2000 -1620 3 1 {name=p211 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2020 -1620 3 1 {name=p212 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 2040 -1620 3 1 {name=p213 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 1990 -1440 3 0 {name=p214 sig_type=std_logic lab="9*VSSd, VDDd"}
C {lab_pin.sym} 2010 -1440 3 0 {name=p215 sig_type=std_logic lab="4*VDDd, VSSd, 5*VDDd"}
C {libs/core_passive_array/sim_cap_10x1p/sim_cap_10x1p.sym} 1550 -1090 3 0 {name=xc2}
C {lab_pin.sym} 1480 -1090 3 0 {name=p218 sig_type=std_logic lab=P24}
C {lab_pin.sym} 1620 -1090 3 0 {name=p219 sig_type=std_logic lab=P25}
C {lab_pin.sym} 1570 -1180 3 1 {name=p220 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 1590 -1180 3 1 {name=p221 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 1540 -1000 3 0 {name=p222 sig_type=std_logic lab="10*VDDd"}
C {lab_pin.sym} 1560 -1000 3 0 {name=p223 sig_type=std_logic lab="10*VSSd"}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 3660 -1570 0 0 {name=x1}
C {lab_pin.sym} 3570 -1600 0 0 {name=p3 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3570 -1580 0 0 {name=p4 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 3750 -1600 0 1 {name=p5 sig_type=std_logic lab=P1}
C {lab_pin.sym} 3750 -1580 0 1 {name=p7 sig_type=std_logic lab=GPIO_A1}
C {lab_pin.sym} 3750 -1540 0 1 {name=p8 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3750 -1560 0 1 {name=p9 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 4060 -1570 0 0 {name=x2}
C {lab_pin.sym} 3970 -1600 0 0 {name=p10 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3970 -1580 0 0 {name=p11 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 4150 -1600 0 1 {name=p16 sig_type=std_logic lab=P49}
C {lab_pin.sym} 4150 -1580 0 1 {name=p17 sig_type=std_logic lab=GPIO_A2}
C {lab_pin.sym} 4150 -1540 0 1 {name=p18 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4150 -1560 0 1 {name=p19 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 4460 -1570 0 0 {name=x3}
C {lab_pin.sym} 4370 -1600 0 0 {name=p20 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4370 -1580 0 0 {name=p21 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 4550 -1600 0 1 {name=p22 sig_type=std_logic lab=P3}
C {lab_pin.sym} 4550 -1580 0 1 {name=p31 sig_type=std_logic lab=GPIO_A3}
C {lab_pin.sym} 4550 -1540 0 1 {name=p32 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4550 -1560 0 1 {name=p33 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 4860 -1570 0 0 {name=x4}
C {lab_pin.sym} 4950 -1600 0 1 {name=p34 sig_type=std_logic lab=P23}
C {lab_pin.sym} 4950 -1580 0 1 {name=p35 sig_type=std_logic lab=GPIO_A4}
C {lab_pin.sym} 4950 -1540 0 1 {name=p36 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4950 -1560 0 1 {name=p37 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 3660 -1470 0 0 {name=x11}
C {lab_pin.sym} 3570 -1500 0 0 {name=p82 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3570 -1480 0 0 {name=p83 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 3750 -1500 0 1 {name=p84 sig_type=std_logic lab=P2}
C {lab_pin.sym} 3750 -1480 0 1 {name=p85 sig_type=std_logic lab=GPIO_A1}
C {lab_pin.sym} 3750 -1440 0 1 {name=p86 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3750 -1460 0 1 {name=p87 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 3660 -1370 0 0 {name=x12}
C {lab_pin.sym} 3570 -1400 0 0 {name=p88 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3570 -1380 0 0 {name=p89 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 3750 -1400 0 1 {name=p90 sig_type=std_logic lab=P47}
C {lab_pin.sym} 3750 -1380 0 1 {name=p91 sig_type=std_logic lab=GPIO_A1}
C {lab_pin.sym} 3750 -1340 0 1 {name=p92 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 3750 -1360 0 1 {name=p93 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 4460 -1470 0 0 {name=x13}
C {lab_pin.sym} 4370 -1500 0 0 {name=p94 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4370 -1480 0 0 {name=p95 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 4550 -1500 0 1 {name=p96 sig_type=std_logic lab=P25}
C {lab_pin.sym} 4550 -1480 0 1 {name=p97 sig_type=std_logic lab=GPIO_A3}
C {lab_pin.sym} 4550 -1440 0 1 {name=p98 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4550 -1460 0 1 {name=p99 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 4460 -1370 0 0 {name=x14}
C {lab_pin.sym} 4370 -1400 0 0 {name=p100 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4370 -1380 0 0 {name=p101 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 4550 -1400 0 1 {name=p102 sig_type=std_logic lab=P48}
C {lab_pin.sym} 4550 -1380 0 1 {name=p103 sig_type=std_logic lab=GPIO_A3}
C {lab_pin.sym} 4550 -1340 0 1 {name=p104 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4550 -1360 0 1 {name=p105 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 4770 -1600 0 0 {name=p106 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4770 -1580 0 0 {name=p107 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 4860 -1470 0 0 {name=x15}
C {lab_pin.sym} 4950 -1500 0 1 {name=p108 sig_type=std_logic lab=P24}
C {lab_pin.sym} 4950 -1480 0 1 {name=p109 sig_type=std_logic lab=GPIO_A4}
C {lab_pin.sym} 4950 -1440 0 1 {name=p110 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4950 -1460 0 1 {name=p111 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 4770 -1500 0 0 {name=p112 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4770 -1480 0 0 {name=p113 sig_type=std_logic lab=VSSd}
C {libs/core_passive_array/sim_res_10x10k/sim_res_10x10k.sym} 2040 -880 0 0 {name=xr2}
C {lab_pin.sym} 2040 -950 0 0 {name=p50 sig_type=std_logic lab=P48}
C {lab_pin.sym} 2040 -810 0 0 {name=p51 sig_type=std_logic lab=P49}
C {lab_pin.sym} 2130 -880 0 1 {name=p58 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2130 -860 0 1 {name=p59 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 2130 -840 0 1 {name=p64 sig_type=std_logic lab=VSSd}
C {libs/core_switch_matrix/tgate_sim/tgate_sim.sym} 4860 -1370 0 0 {name=x5}
C {lab_pin.sym} 4950 -1400 0 1 {name=p12 sig_type=std_logic lab=P46}
C {lab_pin.sym} 4950 -1380 0 1 {name=p13 sig_type=std_logic lab=GPIO_A4}
C {lab_pin.sym} 4950 -1340 0 1 {name=p14 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4950 -1360 0 1 {name=p15 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 4770 -1400 0 0 {name=p25 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 4770 -1380 0 0 {name=p26 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 1950 -890 0 0 {name=p27 sig_type=std_logic lab="9*VSSd, VDDd"}
C {lab_pin.sym} 1950 -870 0 0 {name=p28 sig_type=std_logic lab="4*VDDd, VSSd, 5*VDDd"}
C {libs/core_passive_array/sim_cap_10x1p/sim_cap_10x1p.sym} 1020 -1090 3 0 {name=xc1}
C {lab_pin.sym} 950 -1090 3 0 {name=p29 sig_type=std_logic lab=P22}
C {lab_pin.sym} 1090 -1090 3 0 {name=p30 sig_type=std_logic lab=P23}
C {lab_pin.sym} 1040 -1180 3 1 {name=p38 sig_type=std_logic lab=VDDd}
C {lab_pin.sym} 1060 -1180 3 1 {name=p39 sig_type=std_logic lab=VSSd}
C {lab_pin.sym} 1010 -1000 3 0 {name=p40 sig_type=std_logic lab="10*VDDd"}
C {lab_pin.sym} 1030 -1000 3 0 {name=p41 sig_type=std_logic lab="10*VSSd"}
