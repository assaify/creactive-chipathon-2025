v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {symbols/cap_mim_2f0fF.sym} 160 -90 1 0 {name=C1
W=10e-6
L=10e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1	}
C {iopin.sym} 130 -90 0 1 {name=p10 lab=A}
C {iopin.sym} 190 -90 0 0 {name=p1 lab=B}
