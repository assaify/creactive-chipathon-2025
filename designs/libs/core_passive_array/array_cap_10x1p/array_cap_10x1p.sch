v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 410 -50 410 -30 {lab=c_b}
N 390 -110 410 -110 {lab=#net1}
N 390 -130 410 -130 {lab=c_a}
N 390 -150 410 -150 {lab=vss}
N 390 -170 410 -170 {lab=vdd}
N 70 -150 90 -150 {lab=clk_2}
N 70 -170 90 -170 {lab=clk_1}
N 70 -130 90 -130 {lab=rst_n}
N 70 -190 90 -190 {lab=data_in}
N 890 -50 890 -30 {lab=c_b}
N 870 -110 890 -110 {lab=#net2}
N 870 -130 890 -130 {lab=c_a}
N 870 -150 890 -150 {lab=vss}
N 870 -170 890 -170 {lab=vdd}
N 550 -150 570 -150 {lab=clk_2}
N 550 -170 570 -170 {lab=clk_1}
N 550 -130 570 -130 {lab=rst_n}
N 390 -190 570 -190 {lab=#net3}
N 1370 -50 1370 -30 {lab=c_b}
N 1350 -110 1370 -110 {lab=#net4}
N 1350 -130 1370 -130 {lab=c_a}
N 1350 -150 1370 -150 {lab=vss}
N 1350 -170 1370 -170 {lab=vdd}
N 1030 -150 1050 -150 {lab=clk_2}
N 1030 -170 1050 -170 {lab=clk_1}
N 1030 -130 1050 -130 {lab=rst_n}
N 870 -190 1050 -190 {lab=#net5}
N 1850 -50 1850 -30 {lab=c_b}
N 1830 -110 1850 -110 {lab=#net6}
N 1830 -130 1850 -130 {lab=c_a}
N 1830 -150 1850 -150 {lab=vss}
N 1830 -170 1850 -170 {lab=vdd}
N 1510 -150 1530 -150 {lab=clk_2}
N 1510 -170 1530 -170 {lab=clk_1}
N 1510 -130 1530 -130 {lab=rst_n}
N 1350 -190 1530 -190 {lab=#net7}
N 2330 -50 2330 -30 {lab=c_b}
N 2310 -110 2330 -110 {lab=#net8}
N 2310 -130 2330 -130 {lab=c_a}
N 2310 -150 2330 -150 {lab=vss}
N 2310 -170 2330 -170 {lab=vdd}
N 1990 -150 2010 -150 {lab=clk_2}
N 1990 -170 2010 -170 {lab=clk_1}
N 1990 -130 2010 -130 {lab=rst_n}
N 1830 -190 2010 -190 {lab=#net9}
N 2800 -50 2800 -30 {lab=c_b}
N 2780 -110 2800 -110 {lab=#net10}
N 2780 -130 2800 -130 {lab=c_a}
N 2780 -150 2800 -150 {lab=vss}
N 2780 -170 2800 -170 {lab=vdd}
N 2460 -150 2480 -150 {lab=clk_2}
N 2460 -170 2480 -170 {lab=clk_1}
N 2460 -130 2480 -130 {lab=rst_n}
N 2300 -190 2480 -190 {lab=#net11}
N 3280 -50 3280 -30 {lab=c_b}
N 3260 -110 3280 -110 {lab=#net12}
N 3260 -130 3280 -130 {lab=c_a}
N 3260 -150 3280 -150 {lab=vss}
N 3260 -170 3280 -170 {lab=vdd}
N 2940 -150 2960 -150 {lab=clk_2}
N 2940 -170 2960 -170 {lab=clk_1}
N 2940 -130 2960 -130 {lab=rst_n}
N 2780 -190 2960 -190 {lab=#net13}
N 3760 -50 3760 -30 {lab=c_b}
N 3740 -110 3760 -110 {lab=#net14}
N 3740 -130 3760 -130 {lab=c_a}
N 3740 -150 3760 -150 {lab=vss}
N 3740 -170 3760 -170 {lab=vdd}
N 3420 -150 3440 -150 {lab=clk_2}
N 3420 -170 3440 -170 {lab=clk_1}
N 3420 -130 3440 -130 {lab=rst_n}
N 3260 -190 3440 -190 {lab=#net15}
N 4240 -50 4240 -30 {lab=c_b}
N 4220 -110 4240 -110 {lab=#net16}
N 4220 -130 4240 -130 {lab=c_a}
N 4220 -150 4240 -150 {lab=vss}
N 4220 -170 4240 -170 {lab=vdd}
N 3900 -150 3920 -150 {lab=clk_2}
N 3900 -170 3920 -170 {lab=clk_1}
N 3900 -130 3920 -130 {lab=rst_n}
N 3740 -190 3920 -190 {lab=#net17}
N 4720 -50 4720 -30 {lab=c_b}
N 4700 -110 4720 -110 {lab=#net18}
N 4700 -130 4720 -130 {lab=c_a}
N 4700 -150 4720 -150 {lab=vss}
N 4700 -170 4720 -170 {lab=vdd}
N 4380 -150 4400 -150 {lab=clk_2}
N 4380 -170 4400 -170 {lab=clk_1}
N 4380 -130 4400 -130 {lab=rst_n}
N 4220 -190 4400 -190 {lab=#net19}
N 4700 -190 4720 -190 {lab=data_out}
C {symbols/cap_mim_2f0fF.sym} 410 -80 0 0 {name=C1
W=10e-6
L=10e-6
model=cap_mim_2f0fF
spiceprefix=X
m=5}
C {devices/lab_pin.sym} 410 -130 0 1 {name=l1 sig_type=std_logic lab=c_a}
C {devices/lab_pin.sym} 410 -30 0 0 {name=l2 sig_type=std_logic lab=c_b}
C {libs/core_switch_matrix/switch-cell/switch-cell.sym} 240 -150 0 0 {name=x1}
C {devices/lab_pin.sym} 410 -150 0 1 {name=l3 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 410 -170 0 1 {name=l4 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 70 -150 0 0 {name=l5 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 70 -170 0 0 {name=l6 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 70 -130 0 0 {name=l7 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 70 -190 0 0 {name=l8 sig_type=std_logic lab=data_in}
C {symbols/cap_mim_2f0fF.sym} 890 -80 0 0 {name=C2
W=10e-6
L=10e-6
model=cap_mim_2f0fF
spiceprefix=X
m=5}
C {devices/lab_pin.sym} 890 -130 0 1 {name=l9 sig_type=std_logic lab=c_a}
C {devices/lab_pin.sym} 890 -30 0 0 {name=l10 sig_type=std_logic lab=c_b}
C {libs/core_switch_matrix/switch-cell/switch-cell.sym} 720 -150 0 0 {name=x2}
C {devices/lab_pin.sym} 890 -150 0 1 {name=l11 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 890 -170 0 1 {name=l12 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 550 -150 0 0 {name=l13 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 550 -170 0 0 {name=l14 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 550 -130 0 0 {name=l15 sig_type=std_logic lab=rst_n}
C {symbols/cap_mim_2f0fF.sym} 1370 -80 0 0 {name=C3
W=10e-6
L=10e-6
model=cap_mim_2f0fF
spiceprefix=X
m=5}
C {devices/lab_pin.sym} 1370 -130 0 1 {name=l16 sig_type=std_logic lab=c_a}
C {devices/lab_pin.sym} 1370 -30 0 0 {name=l17 sig_type=std_logic lab=c_b}
C {libs/core_switch_matrix/switch-cell/switch-cell.sym} 1200 -150 0 0 {name=x3}
C {devices/lab_pin.sym} 1370 -150 0 1 {name=l18 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 1370 -170 0 1 {name=l19 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1030 -150 0 0 {name=l20 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 1030 -170 0 0 {name=l21 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 1030 -130 0 0 {name=l22 sig_type=std_logic lab=rst_n}
C {symbols/cap_mim_2f0fF.sym} 1850 -80 0 0 {name=C4
W=10e-6
L=10e-6
model=cap_mim_2f0fF
spiceprefix=X
m=5}
C {devices/lab_pin.sym} 1850 -130 0 1 {name=l23 sig_type=std_logic lab=c_a}
C {devices/lab_pin.sym} 1850 -30 0 0 {name=l24 sig_type=std_logic lab=c_b}
C {libs/core_switch_matrix/switch-cell/switch-cell.sym} 1680 -150 0 0 {name=x4}
C {devices/lab_pin.sym} 1850 -150 0 1 {name=l25 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 1850 -170 0 1 {name=l26 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1510 -150 0 0 {name=l27 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 1510 -170 0 0 {name=l28 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 1510 -130 0 0 {name=l29 sig_type=std_logic lab=rst_n}
C {symbols/cap_mim_2f0fF.sym} 2330 -80 0 0 {name=C5
W=10e-6
L=10e-6
model=cap_mim_2f0fF
spiceprefix=X
m=5}
C {devices/lab_pin.sym} 2330 -130 0 1 {name=l30 sig_type=std_logic lab=c_a}
C {devices/lab_pin.sym} 2330 -30 0 0 {name=l31 sig_type=std_logic lab=c_b}
C {libs/core_switch_matrix/switch-cell/switch-cell.sym} 2160 -150 0 0 {name=x5}
C {devices/lab_pin.sym} 2330 -150 0 1 {name=l32 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 2330 -170 0 1 {name=l33 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1990 -150 0 0 {name=l34 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 1990 -170 0 0 {name=l35 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 1990 -130 0 0 {name=l36 sig_type=std_logic lab=rst_n}
C {symbols/cap_mim_2f0fF.sym} 2800 -80 0 0 {name=C6
W=10e-6
L=10e-6
model=cap_mim_2f0fF
spiceprefix=X
m=5}
C {devices/lab_pin.sym} 2800 -130 0 1 {name=l37 sig_type=std_logic lab=c_a}
C {devices/lab_pin.sym} 2800 -30 0 0 {name=l38 sig_type=std_logic lab=c_b}
C {libs/core_switch_matrix/switch-cell/switch-cell.sym} 2630 -150 0 0 {name=x6}
C {devices/lab_pin.sym} 2800 -150 0 1 {name=l39 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 2800 -170 0 1 {name=l40 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2460 -150 0 0 {name=l41 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 2460 -170 0 0 {name=l42 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 2460 -130 0 0 {name=l43 sig_type=std_logic lab=rst_n}
C {symbols/cap_mim_2f0fF.sym} 3280 -80 0 0 {name=C7
W=10e-6
L=10e-6
model=cap_mim_2f0fF
spiceprefix=X
m=5}
C {devices/lab_pin.sym} 3280 -130 0 1 {name=l44 sig_type=std_logic lab=c_a}
C {devices/lab_pin.sym} 3280 -30 0 0 {name=l45 sig_type=std_logic lab=c_b}
C {libs/core_switch_matrix/switch-cell/switch-cell.sym} 3110 -150 0 0 {name=x7}
C {devices/lab_pin.sym} 3280 -150 0 1 {name=l46 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 3280 -170 0 1 {name=l47 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2940 -150 0 0 {name=l48 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 2940 -170 0 0 {name=l49 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 2940 -130 0 0 {name=l50 sig_type=std_logic lab=rst_n}
C {symbols/cap_mim_2f0fF.sym} 3760 -80 0 0 {name=C8
W=10e-6
L=10e-6
model=cap_mim_2f0fF
spiceprefix=X
m=5}
C {devices/lab_pin.sym} 3760 -130 0 1 {name=l51 sig_type=std_logic lab=c_a}
C {devices/lab_pin.sym} 3760 -30 0 0 {name=l52 sig_type=std_logic lab=c_b}
C {libs/core_switch_matrix/switch-cell/switch-cell.sym} 3590 -150 0 0 {name=x8}
C {devices/lab_pin.sym} 3760 -150 0 1 {name=l53 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 3760 -170 0 1 {name=l54 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 3420 -150 0 0 {name=l55 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 3420 -170 0 0 {name=l56 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 3420 -130 0 0 {name=l57 sig_type=std_logic lab=rst_n}
C {symbols/cap_mim_2f0fF.sym} 4240 -80 0 0 {name=C9
W=10e-6
L=10e-6
model=cap_mim_2f0fF
spiceprefix=X
m=5}
C {devices/lab_pin.sym} 4240 -130 0 1 {name=l58 sig_type=std_logic lab=c_a}
C {devices/lab_pin.sym} 4240 -30 0 0 {name=l59 sig_type=std_logic lab=c_b}
C {libs/core_switch_matrix/switch-cell/switch-cell.sym} 4070 -150 0 0 {name=x9}
C {devices/lab_pin.sym} 4240 -150 0 1 {name=l60 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 4240 -170 0 1 {name=l61 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 3900 -150 0 0 {name=l62 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 3900 -170 0 0 {name=l63 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 3900 -130 0 0 {name=l64 sig_type=std_logic lab=rst_n}
C {symbols/cap_mim_2f0fF.sym} 4720 -80 0 0 {name=C10
W=10e-6
L=10e-6
model=cap_mim_2f0fF
spiceprefix=X
m=5}
C {devices/lab_pin.sym} 4720 -130 0 1 {name=l65 sig_type=std_logic lab=c_a}
C {devices/lab_pin.sym} 4720 -30 0 0 {name=l66 sig_type=std_logic lab=c_b}
C {libs/core_switch_matrix/switch-cell/switch-cell.sym} 4550 -150 0 0 {name=x10}
C {devices/lab_pin.sym} 4720 -150 0 1 {name=l67 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 4720 -170 0 1 {name=l68 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4380 -150 0 0 {name=l69 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 4380 -170 0 0 {name=l70 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 4380 -130 0 0 {name=l71 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 4720 -190 0 1 {name=l72 sig_type=std_logic lab=data_out}
C {iopin.sym} 0 -430 0 0 {name=p1 lab=vdd}
C {iopin.sym} 0 -410 0 0 {name=p2 lab=vss}
C {iopin.sym} 0 -390 0 0 {name=p3 lab=c_a}
C {iopin.sym} 0 -370 0 0 {name=p4 lab=c_b}
C {ipin.sym} 0 -350 0 0 {name=p5 lab=data_in}
C {ipin.sym} 0 -330 0 0 {name=p6 lab=clk_1}
C {ipin.sym} 0 -310 0 0 {name=p7 lab=clk_2}
C {ipin.sym} 0 -290 0 0 {name=p8 lab=rst_n}
