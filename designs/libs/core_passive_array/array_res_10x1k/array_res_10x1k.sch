v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 400 -240 400 -160 {lab=#net1}
N 400 -260 420 -260 {lab=r_b}
N 400 -280 420 -280 {lab=vss}
N 400 -300 420 -300 {lab=vdd}
N 80 -280 100 -280 {lab=clk_2}
N 80 -300 100 -300 {lab=clk_1}
N 80 -260 100 -260 {lab=rst_n}
N 80 -320 100 -320 {lab=data_in}
N 400 -320 580 -320 {lab=#net2}
N 400 -160 820 -160 {lab=#net1}
N 320 -160 340 -160 {lab=r_a}
N 880 -260 900 -260 {lab=r_b}
N 880 -280 900 -280 {lab=vss}
N 880 -300 900 -300 {lab=vdd}
N 560 -280 580 -280 {lab=clk_2}
N 560 -300 580 -300 {lab=clk_1}
N 560 -260 580 -260 {lab=rst_n}
N 880 -240 880 -160 {lab=#net1}
N 880 -320 1060 -320 {lab=#net2}
N 880 -160 1300 -160 {lab=#net1}
N 1360 -260 1380 -260 {lab=r_b}
N 1360 -280 1380 -280 {lab=vss}
N 1360 -300 1380 -300 {lab=vdd}
N 1040 -280 1060 -280 {lab=clk_2}
N 1040 -300 1060 -300 {lab=clk_1}
N 1040 -260 1060 -260 {lab=rst_n}
N 1360 -240 1360 -160 {lab=#net1}
N 1360 -320 1540 -320 {lab=#net2}
N 1360 -160 1780 -160 {lab=#net1}
N 1840 -260 1860 -260 {lab=r_b}
N 1840 -280 1860 -280 {lab=vss}
N 1840 -300 1860 -300 {lab=vdd}
N 1520 -280 1540 -280 {lab=clk_2}
N 1520 -300 1540 -300 {lab=clk_1}
N 1520 -260 1540 -260 {lab=rst_n}
N 1840 -240 1840 -160 {lab=#net1}
N 1840 -320 2020 -320 {lab=#net2}
N 1840 -160 2260 -160 {lab=#net1}
N 2320 -260 2340 -260 {lab=r_b}
N 2320 -280 2340 -280 {lab=vss}
N 2320 -300 2340 -300 {lab=vdd}
N 2000 -280 2020 -280 {lab=clk_2}
N 2000 -300 2020 -300 {lab=clk_1}
N 2000 -260 2020 -260 {lab=rst_n}
N 2320 -240 2320 -160 {lab=#net1}
N 2320 -320 2500 -320 {lab=#net2}
N 2320 -160 2740 -160 {lab=#net1}
N 2800 -260 2820 -260 {lab=r_b}
N 2800 -280 2820 -280 {lab=vss}
N 2800 -300 2820 -300 {lab=vdd}
N 2480 -280 2500 -280 {lab=clk_2}
N 2480 -300 2500 -300 {lab=clk_1}
N 2480 -260 2500 -260 {lab=rst_n}
N 2800 -240 2800 -160 {lab=#net1}
N 2800 -320 2980 -320 {lab=#net2}
N 2800 -160 3220 -160 {lab=#net1}
N 3280 -260 3300 -260 {lab=r_b}
N 3280 -280 3300 -280 {lab=vss}
N 3280 -300 3300 -300 {lab=vdd}
N 2960 -280 2980 -280 {lab=clk_2}
N 2960 -300 2980 -300 {lab=clk_1}
N 2960 -260 2980 -260 {lab=rst_n}
N 3280 -240 3280 -160 {lab=#net1}
N 3280 -320 3460 -320 {lab=#net2}
N 3280 -160 3700 -160 {lab=#net1}
N 3760 -260 3780 -260 {lab=r_b}
N 3760 -280 3780 -280 {lab=vss}
N 3760 -300 3780 -300 {lab=vdd}
N 3440 -280 3460 -280 {lab=clk_2}
N 3440 -300 3460 -300 {lab=clk_1}
N 3440 -260 3460 -260 {lab=rst_n}
N 3760 -240 3760 -160 {lab=#net1}
N 3760 -320 3940 -320 {lab=#net2}
N 3760 -160 4180 -160 {lab=#net1}
N 4240 -260 4260 -260 {lab=r_b}
N 4240 -280 4260 -280 {lab=vss}
N 4240 -300 4260 -300 {lab=vdd}
N 3920 -280 3940 -280 {lab=clk_2}
N 3920 -300 3940 -300 {lab=clk_1}
N 3920 -260 3940 -260 {lab=rst_n}
N 4240 -240 4240 -160 {lab=#net1}
N 4240 -320 4420 -320 {lab=#net2}
N 4240 -160 4660 -160 {lab=#net1}
N 4720 -260 4740 -260 {lab=r_b}
N 4720 -280 4740 -280 {lab=vss}
N 4720 -300 4740 -300 {lab=vdd}
N 4400 -280 4420 -280 {lab=clk_2}
N 4400 -300 4420 -300 {lab=clk_1}
N 4400 -260 4420 -260 {lab=rst_n}
N 4720 -240 4720 -160 {lab=#net1}
N 4720 -320 4740 -320 {lab=data_out}
C {symbols/ppolyf_u.sym} 370 -160 1 0 {name=R1
W=1e-6
L=2.2e-6
model=ppolyf_u
spiceprefix=X
m=1}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 250 -280 0 0 {name=x1}
C {devices/lab_pin.sym} 420 -260 0 1 {name=l1 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 420 -280 0 1 {name=l3 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 420 -300 0 1 {name=l4 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 80 -280 0 0 {name=l5 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 80 -300 0 0 {name=l6 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 80 -260 0 0 {name=l7 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 80 -320 0 0 {name=l8 sig_type=std_logic lab=data_in}
C {devices/lab_pin.sym} 420 -260 0 1 {name=l2 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 370 -180 0 0 {name=l17 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 320 -160 0 0 {name=l83 sig_type=std_logic lab=r_a}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 730 -280 0 0 {name=x2}
C {devices/lab_pin.sym} 900 -260 0 1 {name=l9 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 900 -280 0 1 {name=l10 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 900 -300 0 1 {name=l11 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 560 -280 0 0 {name=l12 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 560 -300 0 0 {name=l13 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 560 -260 0 0 {name=l14 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 900 -260 0 1 {name=l15 sig_type=std_logic lab=r_b}
C {symbols/ppolyf_u.sym} 850 -160 1 0 {name=R2
W=1e-6
L=2.2e-6
model=ppolyf_u
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 850 -180 0 0 {name=l16 sig_type=std_logic lab=vdd}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 1210 -280 0 0 {name=x3}
C {devices/lab_pin.sym} 1380 -260 0 1 {name=l18 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 1380 -280 0 1 {name=l19 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 1380 -300 0 1 {name=l20 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1040 -280 0 0 {name=l21 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 1040 -300 0 0 {name=l22 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 1040 -260 0 0 {name=l23 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 1380 -260 0 1 {name=l24 sig_type=std_logic lab=r_b}
C {symbols/ppolyf_u.sym} 1330 -160 1 0 {name=R3
W=1e-6
L=2.2e-6
model=ppolyf_u
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 1330 -180 0 0 {name=l25 sig_type=std_logic lab=vdd}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 1690 -280 0 0 {name=x4}
C {devices/lab_pin.sym} 1860 -260 0 1 {name=l26 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 1860 -280 0 1 {name=l27 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 1860 -300 0 1 {name=l28 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1520 -280 0 0 {name=l29 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 1520 -300 0 0 {name=l30 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 1520 -260 0 0 {name=l31 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 1860 -260 0 1 {name=l32 sig_type=std_logic lab=r_b}
C {symbols/ppolyf_u.sym} 1810 -160 1 0 {name=R4
W=1e-6
L=2.2e-6
model=ppolyf_u
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 1810 -180 0 0 {name=l33 sig_type=std_logic lab=vdd}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 2170 -280 0 0 {name=x5}
C {devices/lab_pin.sym} 2340 -260 0 1 {name=l34 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 2340 -280 0 1 {name=l35 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 2340 -300 0 1 {name=l36 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2000 -280 0 0 {name=l37 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 2000 -300 0 0 {name=l38 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 2000 -260 0 0 {name=l39 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 2340 -260 0 1 {name=l40 sig_type=std_logic lab=r_b}
C {symbols/ppolyf_u.sym} 2290 -160 1 0 {name=R5
W=1e-6
L=2.2e-6
model=ppolyf_u
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 2290 -180 0 0 {name=l41 sig_type=std_logic lab=vdd}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 2650 -280 0 0 {name=x6}
C {devices/lab_pin.sym} 2820 -260 0 1 {name=l42 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 2820 -280 0 1 {name=l43 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 2820 -300 0 1 {name=l44 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2480 -280 0 0 {name=l45 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 2480 -300 0 0 {name=l46 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 2480 -260 0 0 {name=l47 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 2820 -260 0 1 {name=l48 sig_type=std_logic lab=r_b}
C {symbols/ppolyf_u.sym} 2770 -160 1 0 {name=R6
W=1e-6
L=2.2e-6
model=ppolyf_u
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 2770 -180 0 0 {name=l49 sig_type=std_logic lab=vdd}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 3130 -280 0 0 {name=x7}
C {devices/lab_pin.sym} 3300 -260 0 1 {name=l50 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 3300 -280 0 1 {name=l51 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 3300 -300 0 1 {name=l52 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2960 -280 0 0 {name=l53 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 2960 -300 0 0 {name=l54 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 2960 -260 0 0 {name=l55 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 3300 -260 0 1 {name=l56 sig_type=std_logic lab=r_b}
C {symbols/ppolyf_u.sym} 3250 -160 1 0 {name=R7
W=1e-6
L=2.2e-6
model=ppolyf_u
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 3250 -180 0 0 {name=l57 sig_type=std_logic lab=vdd}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 3610 -280 0 0 {name=x8}
C {devices/lab_pin.sym} 3780 -260 0 1 {name=l58 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 3780 -280 0 1 {name=l59 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 3780 -300 0 1 {name=l60 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 3440 -280 0 0 {name=l61 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 3440 -300 0 0 {name=l62 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 3440 -260 0 0 {name=l63 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 3780 -260 0 1 {name=l64 sig_type=std_logic lab=r_b}
C {symbols/ppolyf_u.sym} 3730 -160 1 0 {name=R8
W=1e-6
L=2.2e-6
model=ppolyf_u
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 3730 -180 0 0 {name=l65 sig_type=std_logic lab=vdd}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 4090 -280 0 0 {name=x9}
C {devices/lab_pin.sym} 4260 -260 0 1 {name=l66 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 4260 -280 0 1 {name=l67 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 4260 -300 0 1 {name=l68 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 3920 -280 0 0 {name=l69 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 3920 -300 0 0 {name=l70 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 3920 -260 0 0 {name=l71 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 4260 -260 0 1 {name=l72 sig_type=std_logic lab=r_b}
C {symbols/ppolyf_u.sym} 4210 -160 1 0 {name=R9
W=1e-6
L=2.2e-6
model=ppolyf_u
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 4210 -180 0 0 {name=l73 sig_type=std_logic lab=vdd}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 4570 -280 0 0 {name=x10}
C {devices/lab_pin.sym} 4740 -260 0 1 {name=l74 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 4740 -280 0 1 {name=l75 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 4740 -300 0 1 {name=l76 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4400 -280 0 0 {name=l77 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 4400 -300 0 0 {name=l78 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 4400 -260 0 0 {name=l79 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 4740 -260 0 1 {name=l80 sig_type=std_logic lab=r_b}
C {symbols/ppolyf_u.sym} 4690 -160 1 0 {name=R10
W=1e-6
L=2.2e-6
model=ppolyf_u
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 4690 -180 0 0 {name=l81 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4740 -320 0 1 {name=l82 sig_type=std_logic lab=data_out}
C {iopin.sym} 0 -580 0 0 {name=p1 lab=vdd}
C {iopin.sym} 0 -560 0 0 {name=p2 lab=vss}
C {iopin.sym} 0 -540 0 0 {name=p3 lab=r_a}
C {iopin.sym} 0 -520 0 0 {name=p4 lab=r_b}
C {ipin.sym} 0 -500 0 0 {name=p5 lab=data_in}
C {ipin.sym} 0 -480 0 0 {name=p6 lab=clk_1}
C {ipin.sym} 0 -460 0 0 {name=p7 lab=clk_2}
C {ipin.sym} 0 -440 0 0 {name=p8 lab=rst_n}
