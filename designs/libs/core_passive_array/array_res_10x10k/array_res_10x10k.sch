v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 380 -220 380 -140 {lab=#net1}
N 380 -240 400 -240 {lab=r_b}
N 380 -260 400 -260 {lab=vss}
N 380 -280 400 -280 {lab=vdd}
N 60 -260 80 -260 {lab=clk_2}
N 60 -280 80 -280 {lab=clk_1}
N 60 -240 80 -240 {lab=rst_n}
N 60 -300 80 -300 {lab=data_in}
N 380 -300 560 -300 {lab=#net2}
N 860 -220 860 -140 {lab=#net3}
N 860 -240 880 -240 {lab=r_b}
N 860 -260 880 -260 {lab=vss}
N 860 -280 880 -280 {lab=vdd}
N 540 -260 560 -260 {lab=clk_2}
N 540 -280 560 -280 {lab=clk_1}
N 540 -240 560 -240 {lab=rst_n}
N 380 -140 800 -140 {lab=#net1}
N 860 -300 1040 -300 {lab=#net4}
N 1340 -220 1340 -140 {lab=#net5}
N 1340 -240 1360 -240 {lab=r_b}
N 1340 -260 1360 -260 {lab=vss}
N 1340 -280 1360 -280 {lab=vdd}
N 1020 -260 1040 -260 {lab=clk_2}
N 1020 -280 1040 -280 {lab=clk_1}
N 1020 -240 1040 -240 {lab=rst_n}
N 860 -140 1280 -140 {lab=#net3}
N 1340 -300 1520 -300 {lab=#net6}
N 1820 -220 1820 -140 {lab=#net7}
N 1820 -240 1840 -240 {lab=r_b}
N 1820 -260 1840 -260 {lab=vss}
N 1820 -280 1840 -280 {lab=vdd}
N 1500 -260 1520 -260 {lab=clk_2}
N 1500 -280 1520 -280 {lab=clk_1}
N 1500 -240 1520 -240 {lab=rst_n}
N 1340 -140 1760 -140 {lab=#net5}
N 1820 -300 2000 -300 {lab=#net8}
N 2300 -220 2300 -140 {lab=#net9}
N 2300 -240 2320 -240 {lab=r_b}
N 2300 -260 2320 -260 {lab=vss}
N 2300 -280 2320 -280 {lab=vdd}
N 1980 -260 2000 -260 {lab=clk_2}
N 1980 -280 2000 -280 {lab=clk_1}
N 1980 -240 2000 -240 {lab=rst_n}
N 1820 -140 2240 -140 {lab=#net7}
N 2300 -300 2480 -300 {lab=#net10}
N 2780 -220 2780 -140 {lab=#net11}
N 2780 -240 2800 -240 {lab=r_b}
N 2780 -260 2800 -260 {lab=vss}
N 2780 -280 2800 -280 {lab=vdd}
N 2460 -260 2480 -260 {lab=clk_2}
N 2460 -280 2480 -280 {lab=clk_1}
N 2460 -240 2480 -240 {lab=rst_n}
N 2300 -140 2720 -140 {lab=#net9}
N 2780 -300 2960 -300 {lab=#net12}
N 3260 -220 3260 -140 {lab=#net13}
N 3260 -240 3280 -240 {lab=r_b}
N 3260 -260 3280 -260 {lab=vss}
N 3260 -280 3280 -280 {lab=vdd}
N 2940 -260 2960 -260 {lab=clk_2}
N 2940 -280 2960 -280 {lab=clk_1}
N 2940 -240 2960 -240 {lab=rst_n}
N 2780 -140 3200 -140 {lab=#net11}
N 3260 -300 3440 -300 {lab=#net14}
N 3740 -220 3740 -140 {lab=#net15}
N 3740 -240 3760 -240 {lab=r_b}
N 3740 -260 3760 -260 {lab=vss}
N 3740 -280 3760 -280 {lab=vdd}
N 3420 -260 3440 -260 {lab=clk_2}
N 3420 -280 3440 -280 {lab=clk_1}
N 3420 -240 3440 -240 {lab=rst_n}
N 3260 -140 3680 -140 {lab=#net13}
N 3750 -300 3930 -300 {lab=#net16}
N 4230 -220 4230 -140 {lab=#net17}
N 4230 -240 4250 -240 {lab=r_b}
N 4230 -260 4250 -260 {lab=vss}
N 4230 -280 4250 -280 {lab=vdd}
N 3910 -260 3930 -260 {lab=clk_2}
N 3910 -280 3930 -280 {lab=clk_1}
N 3910 -240 3930 -240 {lab=rst_n}
N 3750 -140 4170 -140 {lab=#net18}
N 4230 -300 4410 -300 {lab=#net19}
N 4710 -220 4710 -140 {lab=#net20}
N 4710 -240 4730 -240 {lab=r_b}
N 4710 -260 4730 -260 {lab=vss}
N 4710 -280 4730 -280 {lab=vdd}
N 4390 -260 4410 -260 {lab=clk_2}
N 4390 -280 4410 -280 {lab=clk_1}
N 4390 -240 4410 -240 {lab=rst_n}
N 4230 -140 4650 -140 {lab=#net17}
N 4710 -300 4730 -300 {lab=data_out}
N 300 -140 320 -140 {lab=r_a}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 230 -260 0 0 {name=x1}
C {symbols/ppolyf_u_1k.sym} 350 -140 1 0 {name=R1
W=1e-6
L=9.5e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 400 -240 0 1 {name=l1 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 400 -260 0 1 {name=l3 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 400 -280 0 1 {name=l4 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 60 -260 0 0 {name=l5 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 60 -280 0 0 {name=l6 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 60 -240 0 0 {name=l7 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 60 -300 0 0 {name=l8 sig_type=std_logic lab=data_in}
C {devices/lab_pin.sym} 400 -240 0 1 {name=l2 sig_type=std_logic lab=r_b}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 710 -260 0 0 {name=x2}
C {symbols/ppolyf_u_1k.sym} 830 -140 1 0 {name=R2
W=1e-6
L=9.5e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 880 -240 0 1 {name=l9 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 880 -260 0 1 {name=l10 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 880 -280 0 1 {name=l11 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 540 -260 0 0 {name=l12 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 540 -280 0 0 {name=l13 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 540 -240 0 0 {name=l14 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 880 -240 0 1 {name=l15 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 830 -160 0 0 {name=l16 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 350 -160 0 0 {name=l17 sig_type=std_logic lab=vdd}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 1190 -260 0 0 {name=x3}
C {symbols/ppolyf_u_1k.sym} 1310 -140 1 0 {name=R3
W=1e-6
L=9.5e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 1360 -240 0 1 {name=l18 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 1360 -260 0 1 {name=l19 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 1360 -280 0 1 {name=l20 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1020 -260 0 0 {name=l21 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 1020 -280 0 0 {name=l22 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 1020 -240 0 0 {name=l23 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 1360 -240 0 1 {name=l24 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 1310 -160 0 0 {name=l25 sig_type=std_logic lab=vdd}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 1670 -260 0 0 {name=x4}
C {symbols/ppolyf_u_1k.sym} 1790 -140 1 0 {name=R4
W=1e-6
L=9.5e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 1840 -240 0 1 {name=l26 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 1840 -260 0 1 {name=l27 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 1840 -280 0 1 {name=l28 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1500 -260 0 0 {name=l29 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 1500 -280 0 0 {name=l30 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 1500 -240 0 0 {name=l31 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 1840 -240 0 1 {name=l32 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 1790 -160 0 0 {name=l33 sig_type=std_logic lab=vdd}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 2150 -260 0 0 {name=x5}
C {symbols/ppolyf_u_1k.sym} 2270 -140 1 0 {name=R5
W=1e-6
L=9.5e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 2320 -240 0 1 {name=l34 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 2320 -260 0 1 {name=l35 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 2320 -280 0 1 {name=l36 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1980 -260 0 0 {name=l37 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 1980 -280 0 0 {name=l38 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 1980 -240 0 0 {name=l39 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 2320 -240 0 1 {name=l40 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 2270 -160 0 0 {name=l41 sig_type=std_logic lab=vdd}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 2630 -260 0 0 {name=x6}
C {symbols/ppolyf_u_1k.sym} 2750 -140 1 0 {name=R6
W=1e-6
L=9.5e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 2800 -240 0 1 {name=l42 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 2800 -260 0 1 {name=l43 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 2800 -280 0 1 {name=l44 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2460 -260 0 0 {name=l45 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 2460 -280 0 0 {name=l46 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 2460 -240 0 0 {name=l47 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 2800 -240 0 1 {name=l48 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 2750 -160 0 0 {name=l49 sig_type=std_logic lab=vdd}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 3110 -260 0 0 {name=x7}
C {symbols/ppolyf_u_1k.sym} 3230 -140 1 0 {name=R7
W=1e-6
L=9.5e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 3280 -240 0 1 {name=l50 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 3280 -260 0 1 {name=l51 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 3280 -280 0 1 {name=l52 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2940 -260 0 0 {name=l53 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 2940 -280 0 0 {name=l54 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 2940 -240 0 0 {name=l55 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 3280 -240 0 1 {name=l56 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 3230 -160 0 0 {name=l57 sig_type=std_logic lab=vdd}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 3590 -260 0 0 {name=x8}
C {symbols/ppolyf_u_1k.sym} 3710 -140 1 0 {name=R8
W=1e-6
L=9.5e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 3760 -240 0 1 {name=l58 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 3760 -260 0 1 {name=l59 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 3760 -280 0 1 {name=l60 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 3420 -260 0 0 {name=l61 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 3420 -280 0 0 {name=l62 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 3420 -240 0 0 {name=l63 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 3760 -240 0 1 {name=l64 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 3710 -160 0 0 {name=l65 sig_type=std_logic lab=vdd}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 4080 -260 0 0 {name=x9}
C {symbols/ppolyf_u_1k.sym} 4200 -140 1 0 {name=R9
W=1e-6
L=9.5e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 4250 -240 0 1 {name=l66 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 4250 -260 0 1 {name=l67 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 4250 -280 0 1 {name=l68 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 3910 -260 0 0 {name=l69 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 3910 -280 0 0 {name=l70 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 3910 -240 0 0 {name=l71 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 4250 -240 0 1 {name=l72 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 4200 -160 0 0 {name=l73 sig_type=std_logic lab=vdd}
C {libs/core_switch-matrix/switch-cell/switch-cell.sym} 4560 -260 0 0 {name=x10}
C {symbols/ppolyf_u_1k.sym} 4680 -140 1 0 {name=R10
W=1e-6
L=9.5e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {devices/lab_pin.sym} 4730 -240 0 1 {name=l74 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 4730 -260 0 1 {name=l75 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 4730 -280 0 1 {name=l76 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4390 -260 0 0 {name=l77 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 4390 -280 0 0 {name=l78 sig_type=std_logic lab=clk_1}
C {devices/lab_pin.sym} 4390 -240 0 0 {name=l79 sig_type=std_logic lab=rst_n}
C {devices/lab_pin.sym} 4730 -240 0 1 {name=l80 sig_type=std_logic lab=r_b}
C {devices/lab_pin.sym} 4680 -160 0 0 {name=l81 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4730 -300 0 1 {name=l82 sig_type=std_logic lab=data_out}
C {devices/lab_pin.sym} 300 -140 0 0 {name=l83 sig_type=std_logic lab=r_a}
C {iopin.sym} 0 -580 0 0 {name=p1 lab=vdd}
C {iopin.sym} 0 -560 0 0 {name=p2 lab=vss}
C {iopin.sym} 0 -540 0 0 {name=p3 lab=r_a}
C {iopin.sym} 0 -520 0 0 {name=p4 lab=r_b}
C {ipin.sym} 0 -500 0 0 {name=p5 lab=data_in}
C {ipin.sym} 0 -480 0 0 {name=p6 lab=clk_1}
C {ipin.sym} 0 -460 0 0 {name=p7 lab=clk_2}
C {ipin.sym} 0 -440 0 0 {name=p8 lab=rst_n}
