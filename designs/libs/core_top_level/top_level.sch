v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {libs/core_analog/single_ended_ota/single_ended_ota.sym} 170 -440 0 0 {name=x1}
C {libs/core_analog/single_ended_ota/single_ended_ota.sym} 170 -340 0 0 {name=x2}
C {libs/core_analog/single_ended_ota/single_ended_ota.sym} 170 -240 0 0 {name=x3}
C {libs/core_analog/differential_ota/differential_ota.sym} 490 -430 0 0 {name=x4}
C {libs/core_analog/differential_ota/differential_ota.sym} 490 -310 0 0 {name=x5}
C {libs/core_analog/differential_ota/differential_ota.sym} 490 -190 0 0 {name=x6}
C {libs/core_passive_array/array_cap_10x1p/array_cap_10x1p.sym} 810 -440 0 0 {name=x7}
C {libs/core_passive_array/array_res_10x10k/array_res_10x10k.sym} 1130 -440 0 0 {name=x10}
C {libs/core_passive_array/array_res_10x1k/array_res_10x1k.sym} 1450 -440 0 0 {name=x13}
C {libs/core_passive_array/array_cap_10x1p/array_cap_10x1p.sym} 810 -320 0 0 {name=x8}
C {libs/core_passive_array/array_cap_10x1p/array_cap_10x1p.sym} 810 -200 0 0 {name=x9}
C {libs/core_passive_array/array_res_10x10k/array_res_10x10k.sym} 1130 -320 0 0 {name=x11}
C {libs/core_passive_array/array_res_10x10k/array_res_10x10k.sym} 1130 -200 0 0 {name=x12}
C {libs/core_passive_array/array_res_10x1k/array_res_10x1k.sym} 1450 -320 0 0 {name=x14}
C {libs/core_passive_array/array_res_10x1k/array_res_10x1k.sym} 1450 -200 0 0 {name=x15}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 1820 -470 0 0 {name=x16}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 1820 -440 0 0 {name=x17}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 1820 -410 0 0 {name=x18}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 1820 -380 0 0 {name=x19}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 1820 -350 0 0 {name=x20}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 1820 -300 0 0 {name=x21}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 1820 -270 0 0 {name=x22}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 1820 -240 0 0 {name=x23}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 1820 -210 0 0 {name=x24}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 1820 -180 0 0 {name=x25}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2150 -470 0 0 {name=x26}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2150 -440 0 0 {name=x27}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2150 -410 0 0 {name=x28}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2150 -380 0 0 {name=x29}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2150 -350 0 0 {name=x30}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2150 -300 0 0 {name=x31}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2150 -270 0 0 {name=x32}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2150 -240 0 0 {name=x33}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2150 -210 0 0 {name=x34}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2150 -180 0 0 {name=x35}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2480 -470 0 0 {name=x36}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2480 -440 0 0 {name=x37}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2480 -410 0 0 {name=x38}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2480 -380 0 0 {name=x39}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2480 -350 0 0 {name=x40}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2480 -300 0 0 {name=x41}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2480 -270 0 0 {name=x42}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2480 -240 0 0 {name=x43}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2480 -210 0 0 {name=x44}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2480 -180 0 0 {name=x45}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2810 -470 0 0 {name=x46}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2810 -440 0 0 {name=x47}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2810 -410 0 0 {name=x48}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2810 -380 0 0 {name=x49}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2810 -350 0 0 {name=x50}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2810 -300 0 0 {name=x51}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2810 -270 0 0 {name=x52}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2810 -240 0 0 {name=x53}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2810 -210 0 0 {name=x54}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 2810 -180 0 0 {name=x55}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3150 -470 0 0 {name=x56}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3150 -440 0 0 {name=x57}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3150 -410 0 0 {name=x58}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3150 -380 0 0 {name=x59}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3150 -350 0 0 {name=x60}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3150 -300 0 0 {name=x61}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3150 -270 0 0 {name=x62}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3150 -240 0 0 {name=x63}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3150 -210 0 0 {name=x64}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3150 -180 0 0 {name=x65}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3480 -470 0 0 {name=x66}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3480 -440 0 0 {name=x67}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3480 -410 0 0 {name=x68}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3480 -380 0 0 {name=x69}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3480 -350 0 0 {name=x70}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3480 -300 0 0 {name=x71}
C {libs/core_switch_matrix/switch_matrix_1x10/switch_matrix_1x10.sym} 3480 -270 0 0 {name=x72}
