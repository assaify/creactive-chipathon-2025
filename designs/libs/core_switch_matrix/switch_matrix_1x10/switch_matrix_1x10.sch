v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {libs/core_switch_matrix/switch-cell/switch-cell.sym} 290 -120 0 0 {name=x[1:10]}
