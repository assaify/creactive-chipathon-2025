v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {symbols/ppolyf_u_1k.sym} 80 -60 0 0 {name=R4
W=13.37e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=10}
C {lab_pin.sym} 60 -60 0 0 {name=p14 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 80 -30 0 0 {name=p1 sig_type=std_logic lab=B}
C {lab_pin.sym} 80 -90 0 0 {name=p2 sig_type=std_logic lab=A}
